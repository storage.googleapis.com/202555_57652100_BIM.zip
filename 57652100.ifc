Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-10-10T12:11:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 10 12:11:50 2024 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\8f93c90a-c7b8-4513-8acb-ad717d5238bc\155b8921-de5c-4307-9b47-7ffdbca5ca23\ifc * Database version: 5507 * Database creation date: Thu Oct 10 12:11:49 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 10 12:11:50 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 10 12:11:50 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 57652100 Spout, L=197, 57652100:57652100 Spout, L=197:492149
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Type: 0
Type - Dimensions - NominalDepth: 217 mm; NominalHeight: 75 mm; NominalWidth: 75 mm
Type - General - Author: BIMStone; BIMObjectName: 57652100; ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_97; Uniclass2015Description: Washbasin spouts; Uniclass2015Reference: Pr_40_20_87_97; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EAN Number: 4015474262225; ETIM Class Number: EC011421 Outlet for sanitary taps; Sales Package dimensions (LxWxH): 240 x 85 x 66; UNSPSC Class Number: 30181807 Spout; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/57652100; 3D View: https://static.hansa.com/3D/57652100; Ambience photo: http://static.hansa.com/ambience/57652100; Catalog Drawing URL: http://static.hansa.com/catdrw/57652100; Category B2B: Accessories; Category B2C: Bathtub & Shower; Color variants: 5765210033; Dimension Drawing URL: http://static.hansa.com/dimdrw/57652100; FDV Document URL: http://www.hansa.com/datasheet/57652100/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/57652100; Group: Spout; Installation and Maintenance Guide URL: http://static.hansa.com/manual/57652100; Interactive AR View URL: https://static.hansa.com/AR/57652100; Manufacturer: HANSA; Market: Austria;Belgium;Switzerland;Czech Republic;Slovakia;Germany;Spain;France;International;Italy;Netherlands;Portugal; Mobile Product Information URL: http://mpi.hansa.com/57652100; Model: 57652100 Spout, L=197; Name_en: 57652100 Spout, L=197; OmniClass Number: 23.45.55.00; Product Code: 57652100; Product Family: HANSALOFT; Product Image URL: http://static.hansa.com/image/57652100; Product URL: http://static.hansa.com/57652100; Spare-Part Information URL: http://static.hansa.com/sp/57652100; Technical DataSheet URL: http://www.hansa.com/datasheet/57652100/en; Type Name: 57652100 Spout, L=197; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Aerator: Hidden aerator; Concealed Parts: Square rosette;Round rosette; Connection Size: G1/2; Flow Rate At 300kPa: 0.0229545 m3/s; Installation Type: Wall mounted; Max. Hot Water Supply: 80 kg/K/s3; Spout Projection: 197 mm; Spout Type: Fixed spout;Casted construction; Surface treatment: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 57652100; Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 57652100; Name: 57652100 Spout, L=197; ReplacementCost: n/a; Shape: Sculptured; Size: 75 x 215 x75 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 57652100 Spout, L=197; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 57652100; Manufacturer: HANSA
Pset_ProductRequirements - Name: 57652100 Spout, L=197; Category: Plumbing Fixtures
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.038175 m2; Volume: 0.00122062 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 57652100: 57652100 Spout, L=197; Family and Type: 57652100: 57652100 Spout, L=197; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 57652100: 57652100 Spout, L=197; Type Id: 57652100: 57652100 Spout, L=197; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
